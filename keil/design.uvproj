# Keil uVision project design.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: design +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../: main.c motor.c sensor.c timer.c
